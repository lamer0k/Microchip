# IAR project LedC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD51J19A Microchip ATSAMD51J19A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\c; $TOOLKIT_DIR$\inc\Microchip\samd51; $TOOLKIT_DIR$\inc\Microchip\samd51\component; $TOOLKIT_DIR$\inc\Microchip\samd51\pio; $TOOLKIT_DIR$\inc\Microchip\samd51\instance; ..\CMSIS\Include; AHardware; Application
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LedC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\SuperUser\Documents\GitHub\E54\Cpp\LedCpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: main.c startup_samd51.c
  group Application
    Application/: utils.h
