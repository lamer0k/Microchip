# IAR project LedCpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD51J19A Microchip ATSAMD51J19A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\c; $TOOLKIT_DIR$\inc\Microchip\samd51; $TOOLKIT_DIR$\inc\Microchip\samd51\component; $TOOLKIT_DIR$\inc\Microchip\samd51\pio; $TOOLKIT_DIR$\inc\Microchip\samd51\instance; ..\CMSIS\Include; AHardware; Application
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: LedCpp.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: LedCpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  group (top)
    ./: main.cpp startup_samd51.cpp
  group AHardware
    AHardware/: button.hpp led.hpp
  group Application
    Application/: ledscontroller.hpp
