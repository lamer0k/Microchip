<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\C\LedC.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Cpp\LedCpp.ewp</path>
    </project>
    <batchBuild />
</workspace>
